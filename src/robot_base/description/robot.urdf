Commit message: Add legacy ODrive ros2_control bench integration and Pi LIO profile

File: src/robot_base/description/robot.urdf (robot description, URDF)
Before this commit: robot box_tank, 7 links, 6 joints
Links:
- link base_link: geometry visual box size=0.30702 0.27004 0.21303
